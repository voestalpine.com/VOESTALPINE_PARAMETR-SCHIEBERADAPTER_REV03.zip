# CATIA V5 part "VOESTALPINE_PARAMETR-SCHIEBERADAPTER_REV03.CATPart"
## Design history (mm, degrees; sets first, then bodies; in a sketch O, H, V are its origin and axes)
(part 3 of 4)
            line L9 (-126.7593, 11.6119) -> (-126.7593, 10.4803)
            line L10 (-126.7593, 10.4803) -> (-124.8339, 10.4803)
            line L11 (-126.3344, 7.5432) -> (-127.8938, 7.5432)
            unspec C4
            unspec C5
            line L12 (-127.7193, 10.5777) -> (-126.1993, 10.5777)
            unspec C6
            line L13 (-125.5744, 9.7332) -> (-125.5744, 8.6185)
            unspec C7
            line L14 (-126.3164, 7.3669) -> (-127.8984, 7.3669)
            unspec C8
            line L15 (-126.1588, 10.0524) -> (-125.9618, 11.6681)
            line L16 (-125.9618, 11.6681) -> (-122.4656, 11.6681)
            line L17 (-122.4656, 11.6681) -> (-122.4656, 13.0306)
            line L18 (-122.4656, 13.0306) -> (-127.0934, 13.0306)
            line L19 (-127.0934, 13.0306) -> (-127.6226, 8.7068)
            line L20 (-127.6226, 8.7068) -> (-126.1701, 8.6224)
            unspec C9
            line L21 (-126.7058, 5.0841) -> (-125.0338, 5.0841)
            unspec C10
            line L22 (-122.14, 11.7048) -> (-122.14, 12.9152)
            line L23 (-122.14, 12.9152) -> (-127.86, 12.9152)
            line L24 (-127.86, 12.9152) -> (-127.86, 11.5415)
            line L25 (-127.86, 11.5415) -> (-123.8909, 11.5415)
            unspec C11
            line L26 (-124.5637, 6.8237) -> (-124.5637, 5.0841)
            line L27 (-124.5637, 5.0841) -> (-122.9817, 5.0841)
            line L28 (-122.9817, 5.0841) -> (-122.9817, 6.8237)
            line L29 (-122.9817, 6.8237) -> (-122.0472, 6.8237)
            line L30 (-122.0472, 6.8237) -> (-122.0472, 8.1073)
            line L31 (-122.0472, 8.1073) -> (-122.9817, 8.1073)
            line L32 (-122.9817, 8.1073) -> (-122.9817, 12.9152)
            line L33 (-122.9817, 12.9152) -> (-124.9916, 12.9152)
            line L34 (-124.9916, 12.9152) -> (-127.9528, 8.2424)
            line L35 (-127.9528, 8.2424) -> (-127.9528, 6.8237)
            line L36 (-127.9528, 6.8237) -> (-124.5637, 6.8237)
            line L37 (-126.7199, 8.0679) -> (-124.5186, 8.0679)
            line L38 (-124.5186, 8.0679) -> (-124.5186, 11.519)
            line L39 (-124.5186, 11.519) -> (-126.7199, 8.0679)
            unspec C12
            unspec C13
            unspec C14
            unspec C15
            line L40 (-123.9393, 11.0842) -> (-122.3067, 11.0842)
            unspec C16
            unspec C17
            unspec C18
            unspec C19
            unspec C20
            unspec C21
            unspec C22
            unspec C23
            unspec C24
            unspec C25
            line L41 (-126.0579, 6.9151) -> (-127.6961, 6.9095)
            unspec C26
            unspec C27
            unspec C28
            unspec C29
            point P71 (-125, 8.9996)
            construction line L42 (-122.1016, 13.0306) -> (-122.1016, 4.9687)
            construction line L43 (-122.1016, 4.9687) -> (-127.8984, 4.9687)
            construction line L44 (-127.8984, 4.9687) -> (-127.8984, 13.0306)
            construction line L45 (-127.8984, 13.0306) -> (-122.1016, 13.0306)
            point P76 (-125, 8.9996)
            construction line L46 (-122.0828, 13.148) -> (-122.0828, 4.8513)
            construction line L47 (-122.0828, 4.8513) -> (-127.9172, 4.8513)
            construction line L48 (-127.9172, 4.8513) -> (-127.9172, 13.148)
            construction line L49 (-127.9172, 13.148) -> (-122.0828, 13.148)
            point P81 (-125, 8.9996)
            construction line L50 (-122.14, 12.9152) -> (-122.14, 5.0841)
            construction line L51 (-122.14, 5.0841) -> (-127.86, 5.0841)
            construction line L52 (-127.86, 5.0841) -> (-127.86, 12.9152)
            construction line L53 (-127.86, 12.9152) -> (-122.14, 12.9152)
            point P86 (-125, 8.9996)
            construction line L54 (-122.1069, 13.1497) -> (-122.1069, 4.8496)
            construction line L55 (-122.1069, 4.8496) -> (-127.8931, 4.8496)
            construction line L56 (-127.8931, 4.8496) -> (-127.8931, 13.1497)
            construction line L57 (-127.8931, 13.1497) -> (-122.1069, 13.1497)
            point P91 (-125, 8.9996)
            construction line L58 (-122.0856, 13.148) -> (-122.0856, 4.8513)
            construction line L59 (-122.0856, 4.8513) -> (-127.9144, 4.8513)
            construction line L60 (-127.9144, 4.8513) -> (-127.9144, 13.148)
            construction line L61 (-127.9144, 13.148) -> (-122.0856, 13.148)
            point P96 (-125, 8.9996)
            construction line L62 (-122.0891, 13.1379) -> (-122.0891, 4.8614)
            construction line L63 (-122.0891, 4.8614) -> (-127.9109, 4.8614)
            construction line L64 (-127.9109, 4.8614) -> (-127.9109, 13.1379)
            construction line L65 (-127.9109, 13.1379) -> (-122.0891, 13.1379)
            point P101 (-125, 8.9996)
            construction line L66 (-122.0472, 12.9152) -> (-122.0472, 5.0841)
            construction line L67 (-122.0472, 5.0841) -> (-127.9528, 5.0841)
            construction line L68 (-127.9528, 5.0841) -> (-127.9528, 12.9152)
            construction line L69 (-127.9528, 12.9152) -> (-122.0472, 12.9152)
            point P106 (-125, 8.9996)
            construction line L70 (-122.1062, 13.14) -> (-122.1062, 4.8593)
            construction line L71 (-122.1062, 4.8593) -> (-127.8938, 4.8593)
            construction line L72 (-127.8938, 4.8593) -> (-127.8938, 13.14)
            construction line L73 (-127.8938, 13.14) -> (-122.1062, 13.14)
            point P111 (-125, 8.9996)
            construction line L74 (-122.1283, 13.0311) -> (-122.1283, 4.9681)
            construction line L75 (-122.1283, 4.9681) -> (-127.8717, 4.9681)
            construction line L76 (-127.8717, 4.9681) -> (-127.8717, 13.0311)
            construction line L77 (-127.8717, 13.0311) -> (-122.1283, 13.0311)
            point P116 (-125, 8.9996)
            construction line L78 (-123.2407, 13.0306) -> (-123.2407, 4.9687)
            construction line L79 (-123.2407, 4.9687) -> (-126.7593, 4.9687)
            construction line L80 (-126.7593, 4.9687) -> (-126.7593, 13.0306)
            construction line L81 (-126.7593, 13.0306) -> (-123.2407, 13.0306)
            curve C30
            curve C31
            curve C32
            curve C33
            curve C34
            curve C35
            curve C36
            curve C37
            curve C38
            curve C39
            point P121 (-125, 8.9996)
            line L82 (-123.5, 9.5996) -> (-123.5, 8.3996)
            line L83 (-123.5, 8.3996) -> (-126.5, 8.3996)
            line L84 (-126.5, 8.3996) -> (-126.5, 9.5996)
            line L85 (-126.5, 9.5996) -> (-123.5, 9.5996)
            curve C40
            line L86 (-125.836, 11.4796) -> (-125.836, 4.9996)
            line L87 (-125.836, 4.9996) -> (-124.164, 4.9996)
            line L88 (-124.164, 4.9996) -> (-124.164, 11.4796)
            line L89 (-124.164, 11.4796) -> (-122.0415, 11.4796)
            line L90 (-122.0415, 11.4796) -> (-122.0415, 12.9996)
            line L91 (-122.0415, 12.9996) -> (-127.9585, 12.9996)
            line L92 (-127.9585, 12.9996) -> (-127.9585, 11.4796)
            line L93 (-127.9585, 11.4796) -> (-125.836, 11.4796)
            unspec C41
            unspec C42
            unspec C43
            unspec C44
            line L94 (-128.24, 12.9996) -> (-128.24, 4.9996)
            line L95 (-128.24, 4.9996) -> (-126.5792, 4.9996)
            line L96 (-126.5792, 4.9996) -> (-126.5792, 8.0116)
            line L97 (-126.5792, 8.0116) -> (-126.1626, 8.4564)
            line L98 (-126.1626, 8.4564) -> (-123.7755, 4.9996)
            line L99 (-123.7755, 4.9996) -> (-121.76, 4.9996)
            line L100 (-121.76, 4.9996) -> (-124.9859, 9.6668)
            line L101 (-124.9859, 9.6668) -> (-121.8276, 12.9996)
            line L102 (-121.8276, 12.9996) -> (-123.9613, 12.9996)
            line L103 (-123.9613, 12.9996) -> (-126.5792, 10.1678)
            line L104 (-126.5792, 10.1678) -> (-126.5792, 12.9996)
            line L105 (-126.5792, 12.9996) -> (-128.24, 12.9996)
            line L106 (-127.5419, 12.9996) -> (-127.5419, 4.9996)
            line L107 (-127.5419, 4.9996) -> (-122.4581, 4.9996)
            line L108 (-122.4581, 4.9996) -> (-122.4581, 6.5197)
            line L109 (-122.4581, 6.5197) -> (-125.8811, 6.5197)
            line L110 (-125.8811, 6.5197) -> (-125.8811, 8.355)
            line L111 (-125.8811, 8.355) -> (-122.8973, 8.355)
            line L112 (-122.8973, 8.355) -> (-122.8973, 9.8863)
            line L113 (-122.8973, 9.8863) -> (-125.8811, 9.8863)
            line L114 (-125.8811, 9.8863) -> (-125.8811, 11.4796)
            line L115 (-125.8811, 11.4796) -> (-122.5482, 11.4796)
            line L116 (-122.5482, 11.4796) -> (-122.5482, 12.9996)
            line L117 (-122.5482, 12.9996) -> (-127.5419, 12.9996)
            line L118 (-127.7723, 13.0001) -> (-127.7723, 5.0001)
            unspec C45
            unspec C46
            line L119 (-126.089, 8.3554) -> (-126.089, 6.5201)
            unspec C47
            line L120 (-126.089, 11.48) -> (-126.089, 9.8868)
            unspec C48
            point P169 (-125, 8.9996)
            construction line L121 (-122.2277, 12.999) -> (-122.2277, 5.0003)
            construction line L122 (-122.2277, 5.0003) -> (-127.7723, 5.0003)
            construction line L123 (-127.7723, 5.0003) -> (-127.7723, 12.999)
            construction line L124 (-127.7723, 12.999) -> (-122.2277, 12.999)
            point P174 (-125, 8.9996)
            construction line L125 (-122.4581, 12.9996) -> (-122.4581, 4.9996)
            construction line L126 (-122.4581, 4.9996) -> (-127.5419, 4.9996)
            construction line L127 (-127.5419, 4.9996) -> (-127.5419, 12.9996)
            construction line L128 (-127.5419, 12.9996) -> (-122.4581, 12.9996)
            point P179 (-125, 8.9996)
            construction line L129 (-121.76, 12.9996) -> (-121.76, 4.9996)
            construction line L130 (-121.76, 4.9996) -> (-128.24, 4.9996)
            construction line L131 (-128.24, 4.9996) -> (-128.24, 12.9996)
            construction line L132 (-128.24, 12.9996) -> (-121.76, 12.9996)
            point P184 (-125, 8.9996)
            construction line L133 (-122.0386, 13.2166) -> (-122.0386, 4.7827)
            construction line L134 (-122.0386, 4.7827) -> (-127.9614, 4.7827)
            construction line L135 (-127.9614, 4.7827) -> (-127.9614, 13.2166)
            construction line L136 (-127.9614, 13.2166) -> (-122.0386, 13.2166)
            point P189 (-125, 8.9996)
            construction line L137 (-122.0415, 12.9996) -> (-122.0415, 4.9996)
            construction line L138 (-122.0415, 4.9996) -> (-127.9585, 4.9996)
            construction line L139 (-127.9585, 4.9996) -> (-127.9585, 12.9996)
            construction line L140 (-127.9585, 12.9996) -> (-122.0415, 12.9996)
            curve C49
            curve C50
            curve C51
            curve C52
            unspec C53
            line L141 (-126.2797, 7.645) -> (-127.9968, 7.645)
            unspec C54
            line L142 (-123.9828, 10.6176) -> (-122.2319, 10.6176)
            point P198 (-125, 8.9996)
            construction line L143 (-122.0032, 13.2118) -> (-122.0032, 4.7875)
            construction line L144 (-122.0032, 4.7875) -> (-127.9968, 4.7875)
            construction line L145 (-127.9968, 4.7875) -> (-127.9968, 13.2118)
            construction line L146 (-127.9968, 13.2118) -> (-122.0032, 13.2118)
            curve C55
            curve C56
            construction line L147 (-125, 8.9996) -> (-125, 0)
            point P203 (-125, 0)
            distance H P116 = 8.9996
            distance V P116 = 125
            coincidence: P116 P111, P111 P106, P106 P101, P101 P71, P71 P76, P116 P81, P116 P86, P116 P91, P116 P96, P116 P121, P121 P169, P169 P174, P174 P179, P179 P184, P184 P198, P198 P189, P203 H
            horizontal: L71 H, L83 H, L126 H, L122 H, L130 H, L134 H, L138 H, L144 H
            vertical: L66 V, L46 V, L58 V, L62 V, L42 V, L54 V, L74 V, L50 V, L80 V, L82 V, L137 V, L133 V, L129 V, L125 V, L121 V, L143 V, L147 V
          Translate11 "Translate_Letter_1": Direction Sketch63.H, ToTransfor Sketch63.C52, Length 0
          Translate12 "Translate_Letter_2": Direction Sketch63.H, ToTransfor Sketch63.C40, Length 6.5 {= Verschiebung_Letter_Bezeichnung}
          Translate13 "Translate_Letter_3": Direction Sketch63.H, ToTransfor Sketch63.C51, Length 13 {= Verschiebung_Letter_Bezeichnung *2}
          Translate14 "Translate_Letter_4": Direction Sketch63.H, ToTransfor Sketch63.C55, Length 19.5 {= Verschiebung_Letter_Bezeichnung *3}
          Translate15 "Translate_Letter_5": Direction Sketch63.H, ToTransfor Sketch63.C40, Length 26 {= Verschiebung_Letter_Bezeichnung *4}
          Translate16 "Translate_Letter_6": Direction Sketch63.H, ToTransfor Sketch63.C35, Length 32.5 {= Verschiebung_Letter_Bezeichnung *5}
          Translate17 "Translate_Letter_7": Direction Sketch63.H, ToTransfor Sketch63.C39, Length 39 {= Verschiebung_Letter_Bezeichnung *6}
          Translate18 "Translate_Letter_8": Direction Sketch63.H, ToTransfor Sketch63.C40, Length 45.5 {= Verschiebung_Letter_Bezeichnung *7}
          Translate19 "Translate_Letter_9": Direction Sketch63.H, ToTransfor Sketch63.C39, Length 52 {= Verschiebung_Letter_Bezeichnung *8}
          Translate20 "Translate_Letter_10": Direction Sketch63.H, ToTransfor Sketch63.C39, Length 58.5 {= Verschiebung_Letter_Bezeichnung *9}
          Translate21 "Translate_Letter_11": Direction Sketch63.H, ToTransfor Sketch63.C40, Length 65 {= Verschiebung_Letter_Bezeichnung *10}
          Translate22 "Translate_Letter_12": Direction Sketch63.H, ToTransfor Sketch63.C40, Length 71.5 {= Verschiebung_Letter_Bezeichnung *11}
          Translate23 "Translate_Letter_13": Direction Sketch63.H, ToTransfor Sketch63.C40, Length 78 {= Verschiebung_Letter_Bezeichnung *12}
          Line8 "Hilfslinie_Mirror_Bezeichnung": type PtDir, RefPoint sketch element, Direction Sketch62.H, Start 0, End 78 {= 12* Verschiebung_Letter_Bezeichnung}
          Scaling14 "Scaling_Letter_1": Reference Extremum7, ToTransfor Translate11, Ratio 0.428571 {= (length(Extremum6) / 1mm) / 175}
          Scaling15 "Scaling_Letter_2": Reference Extremum7, ToTransfor Translate12, Ratio 0.428571 {= (length(Extremum6) / 1mm) / 175}
          Scaling16 "Scaling_Letter_3": Reference Extremum7, ToTransfor Translate13, Ratio 0.428571 {= (length(Extremum6) / 1mm) / 175}
          Scaling17 "Scaling_Letter_4": Reference Extremum7, ToTransfor Translate14, Ratio 0.428571 {= (length(Extremum6) / 1mm) / 175}
          Scaling18 "Scaling_Letter_5": Reference Extremum7, ToTransfor Translate15, Ratio 0.428571 {= (length(Extremum6) / 1mm) / 175}
          Scaling19 "Scaling_Letter_6": Reference Extremum7, ToTransfor Translate16, Ratio 0.428571 {= (length(Extremum6) / 1mm) / 175}
          Scaling20 "Scaling_Letter_7": Reference Extremum7, ToTransfor Translate17, Ratio 0.428571 {= (length(Extremum6) / 1mm) / 175}
          Scaling21 "Scaling_Letter_8": Reference Extremum7, ToTransfor Translate18, Ratio 0.428571 {= (length(Extremum6) / 1mm) / 175}
          Scaling22 "Scaling_Letter_9": Reference Extremum7, ToTransfor Translate19, Ratio 0.428571 {= (length(Extremum6) / 1mm) / 175}
          Scaling23 "Scaling_Letter_10": Reference Extremum7, ToTransfor Translate20, Ratio 0.428571 {= (length(Extremum6) / 1mm) / 175}
          Scaling24 "Scaling_Letter_11": Reference Extremum7, ToTransfor Translate21, Ratio 0.428571 {= (length(Extremum6) / 1mm) / 175}
          Scaling25 "Scaling_Letter_12": Reference Extremum7, ToTransfor Translate22, Ratio 0.428571 {= (length(Extremum6) / 1mm) / 175}
          Scaling26 "Scaling_Letter_13": Reference Extremum7, ToTransfor Translate23, Ratio 0.428571 {= (length(Extremum6) / 1mm) / 175}
          Scaling27 "Scaling_Hilfslinie_Mirror_Bezeichnung": Reference Extremum7, ToTransfor Line8, Ratio 0.428571 {= (length(Extremum6) / 1mm) / 175}
          Plane26 "MirrorPlane_Bezeichnungsgravur": type Normal, Curve Scaling27, Ratio 0
    Set26 "Bauraum_Geometrie"
      Set27 "Treiber_Hilfselemente"
        Plane27 "Treiber_Plane_X_Direction": type Offset, RefPlane YZ plane of AxisSystem5, Offset 0
        Plane28 "Treiber_Plane_Y_Direction": type Offset, RefPlane ZX plane of AxisSystem5, Offset 0
        Plane29 "Treiber_Plane_Z_Direction": type Offset, RefPlane XY plane of AxisSystem5, Offset 0
        Extremum8 "Treiber_Extremum_X_Max": Reference Body51, Direction edge [XY plane of AxisSystem5 | ZX plane of AxisSystem5], Direction2 (0, 0, 1), Direction3 (0, 0, 1)
        Extremum9 "Treiber_Extremum_Y_Max": Reference Body51, Direction edge [YZ plane of AxisSystem5 | XY plane of AxisSystem5], Direction2 (0, 0, 1), Direction3 (0, 0, 1)
        Extremum10 "Treiber_Extremum_Z_Max": Reference Body51, Direction edge [ZX plane of AxisSystem5 | YZ plane of AxisSystem5], Direction2 (0, 0, 1), Direction3 (0, 0, 1)
        Sketch64 "Treiber_Skizze_Bauraum" on ZX plane of AxisSystem5, origin (90, 0, 125), H (0, 0, -1), V (-1, 0, 0)
          line L1 (0, 0) -> (135, 0)
          line L2 (135, 0) -> (135, 52.9)
          line L3 (135, 52.9) -> (0, 52.9)
          line L4 (0, 52.9) -> (0, 0)
          distance L3 L1 = 52.9 {= Treiber_Absolutmass_Z}
          distance L4 L2 = 135 {= Treiber_Absolutmass_X}
          horizontal: L1 H, L3 H
          vertical: L2 V, L4 V
      Set28 "Schieberbett_Hilfselemente"
        Plane30 "Schieberbett_Plane_X_Direction": type Offset, RefPlane YZ plane of AxisSystem4, Offset 0
        Plane31 "Schieberbett_Plane_Y_Direction": type Offset, RefPlane ZX plane of AxisSystem4, Offset 0
        Plane32 "Schieberbett_Plane_Z_Direction": type Offset, RefPlane XY plane of AxisSystem4, Offset 0
        Extremum11 "Schieberbett_Extremum_X_Max": Reference Body36, Direction edge [XY plane of AxisSystem4 | ZX plane of AxisSystem4], Direction2 (0, 0, 1), Direction3 (0, 0, 1)
        Extremum12 "Schieberbett_Extremum_Y_Max": Reference Body36, Direction edge [YZ plane of AxisSystem4 | XY plane of AxisSystem4], Direction2 (0, 0, 1), Direction3 (0, 0, 1)
        Extremum13 "Schieberbett_Extremum_Z_Max": Reference Body36, Direction edge [ZX plane of AxisSystem4 | YZ plane of AxisSystem4], Direction2 (0, 0, 1), Direction3 (0, 0, 1)
        Sketch65 "Schieberbett_Skizze_Bauraum" on ZX plane of AxisSystem4, origin (-115, 0, 165), H (0, 0, -1), V (1, 0, 0)
          line L1 (0, 0) -> (195, 0)
          line L2 (195, 0) -> (195, 150)
          line L3 (195, 150) -> (0, 150)
          line L4 (0, 150) -> (0, 0)
          distance L3 L1 = 150 {= Schieberbett_Absolutmass_Z}
          distance L4 L2 = 195 {= Schieberbett_Absolutmass_X}
          horizontal: L1 H, L3 H
          vertical: L2 V, L4 V
      Set29 "Schieberkoerper_Hilfselemente"
        Plane33 "Schieberkoerper_Plane_X_Direction": type Offset, RefPlane YZ plane of AxisSystem6, Offset 0
        Plane34 "Schieberkoerper_Plane_Y_Direction": type Offset, RefPlane ZX plane of AxisSystem6, Offset 0
        Plane35 "Schieberkoerper_Plane_Z_Direction": type Offset, RefPlane XY plane of AxisSystem6, Offset 0
        Extremum14 "Schieberkoerper_Extremum_X_Min": Reference Body1, Direction edge [XY plane of AxisSystem6 | ZX plane of AxisSystem6], Direction2 (0, 0, 1), Direction3 (0, 0, 1)
        Extremum15 "Schieberkoerper_Extremum_X_Max": Reference Body1, Direction edge [XY plane of AxisSystem6 | ZX plane of AxisSystem6], Direction2 (0, 0, 1), Direction3 (0, 0, 1)
        Extremum16 "Schieberkoerper_Extremum_Y_Min": Reference Body1, Direction edge [YZ plane of AxisSystem6 | XY plane of AxisSystem6], Direction2 (0, 0, 1), Direction3 (0, 0, 1)
        Extremum17 "Schieberkoerper_Extremum_Y_Max": Reference Body1, Direction edge [YZ plane of AxisSystem6 | XY plane of AxisSystem6], Direction2 (0, 0, 1), Direction3 (0, 0, 1)
        Extremum18 "Schieberkoerper_Extremum_Z_Min": Reference Body1, Direction edge [ZX plane of AxisSystem6 | YZ plane of AxisSystem6], Direction2 (0, 0, 1), Direction3 (0, 0, 1)
        Extremum19 "Schieberkoerper_Extremum_Z_Max": Reference Body1, Direction edge [ZX plane of AxisSystem6 | YZ plane of AxisSystem6], Direction2 (0, 0, 1), Direction3 (0, 0, 1)
        Sketch66 "Schieberkoerper_Skizze_Bauraum" on ZX plane of AxisSystem6, origin (0, 0, 0), H (-1, 0, 0), V (0, 0, 1)
          line L1 (82.5359, -5) -> (-75, -5)
          line L2 (-75, -5) -> (-75, 103.4581)
          line L3 (-75, 103.4581) -> (82.5359, 103.4581)
          line L4 (82.5359, 103.4581) -> (82.5359, -5)
          construction line L5 (0, 1) -> (15, 1)
          point P5 (0, 1)
          distance V L2 = 75 {= Schieberkoerper_Absolutmass_X_Max}
          distance V L4 = 82.5359 {= Schieberkoerper_Absolutmass_X_Min}
          distance H L3 = 103.4581 {= Schieberkoerper_Absolutmass_Z_Max}
          distance H L5 = 1
          length L5 = 15
          distance L5 L1 = 6 {= Schieberkoerper_Absolutmass_Z_Min + 1mm}
          horizontal: L1 H, L3 H, L5 H
          vertical: L2 V, L4 V
          coincidence: P5 V
Set30 "ELEMENTE_FUER_REPLACE"
  AxisSystem10 "Axis_Schieberrichtung_im_Einfuegepunkt_zum_Ersetzen": origin (0, 0, 0), X (1, 0, 0), Y (0, 1, 0), Z (0, 0, 1)
Set31 "SCHIEBERBETT_Bohrskizzen_und_Bohrebenen"
  Plane36 "SCHIEBERBETT_Bohrebene": type Offset, RefPlane XY plane of AxisSystem4, Offset 0
  Sketch67 "SCHIEBERBETT_Bohrsketch_Gewinde" on Plane36, origin (-115, 0, 165), H (0, 0, -1), V (0, 1, 0)
    construction circle A1 centre (0, 0) radius 0.2716
    projected point E1 (14, 17.5) from sketch element
    projected point E2 (184, 17.5) from sketch element
    projected point E3 (1, 1) from sketch element
    projected point E4 (1, 1) from sketch element
    projected point E5 (1, 1) from sketch element
    projected point E6 (1, 1) from sketch element
    point P1 (14, -17.5)
    point P2 (184, -17.5)
    point P3 (1, -1)
    point P4 (1, -1)
    point P5 (1, -1)
    point P6 (1, -1)
    symmetry: E1 P1 H, E2 P2 H, E3 P3 H, E4 P4 H, E5 P5 H, E6 P6 H
  Sketch68 "SCHIEBERBETT_Bohrsketch_Passungen" on Plane36, origin (-115, 0, 165), H (0, 0, -1), V (0, 1, 0)
    projected point E1 (14, 0) from sketch element
    projected point E2 (182, 0) from sketch element
Set32 "TREIBER_Bohrskizzen_und_Bohrebenen"
  Plane37 "TREIBER_Bohrebene": type Offset, RefPlane XY plane of AxisSystem5, Offset 0
  Sketch69 "TREIBER_Bohrsketch_Gewinde" on Plane37, origin (90, 0, 125), H (0, 0, -1), V (0, -1, 0)
    construction circle A1 centre (0, 0) radius 0.2716
    projected point E1 (12, 20) from sketch element
    projected point E2 (107, 0) from sketch element
    point P1 (12, -20)
    point P2 (107, 0)
    symmetry: E1 P1 H, E2 P2 H
  Sketch70 "TREIBER_Bohrsketch_Passungen" on Plane37, origin (90, 0, 125), H (0, 0, -1), V (0, -1, 0)
    projected point E1 (12, 0) from sketch element
    projected point E2 (122, 0) from sketch element
Set33 "KRAFTFELD"
  Join5 "Kraftfeld_Parzellen": Elements (Extrude2; RectPattern1)
  Join6 "Kraftfelder_Zahlen": Elements DatumCurve13
Set34 "HINWEISTEXTE"
  Join7 "FREIRAUM_ZW_TREIBERN_BEI_KS-OT": Elements Translate2
Body1 "SCHIEBERKOERPER_Fertigteil" (main body)
  Body2 "Rohteil"
    Body3 "Grundkoerper"
      Body4 "SCHIEBERKOERPER_WERKZEUG_GESCHLOSSEN"
        Pad1 "Pad_Schieberkoerper_Arbeitsflaeche": profile Sketch40, direction (0, 0, -1), length -26 {= - SAd}
        Body5 "Body_Abzug_Schieberkoerper_Profil_KS-OT"
          Pocket1 "Pocket_Abzug_Schieberkoerper_Profil_KS-OT": profile CurvePar5, length 1500, mirrored extent, deactivated
        Remove1 "Remove_Abzug_Schieberkoerper_Profil_KS-OT": tool Body5, deactivated
        Body6 "Body_Schieberkoerper_Profil_Fuehrung"
          Pad2 "Pad_Schieberkoerper_Profil_Fuehrung": profile Sketch42, direction (-0.766, 0, -0.6428), length -79.5 {= - S1}
          Split1 "Split_Schieberkoerper_Arbeitsflaeche": SplitPlane Plane9
        Add1 "Add_Schieberkoerper_Profil_Fuehrung": tool Body6
        Body7 "Body_Schieberkoerper_Arbeitsflaeche_Schulter"
          Pad3 "Pad_Schieberkoerper_Arbeitsflaeche_Schulter": profile Sketch47, direction (0, 1, 0), length -30 {= - SAb}
        Add2 "Add_Schieberkoerper_Arbeitsflaeche_Schulter": tool Body7
        Pad4 "Pad_Schieberkoerper_Treibergleitflaeche": profile Sketch41, direction (0, 0, -1), length -81.5 {= - S10}
        Body8 "Body_Abzug_Treiber"
          Pocket2 "Pocket_Schieberkoerper_Abzug_Treibergleitflaeche": profile Sketch44, direction (0, 0, 1), length 500, mirrored extent
          Pocket3 "Pocket_Schieberkoerper_Abzug_Arbeitsflaeche_Unterkante": profile Sketch45, direction (0, 0, 1), length 500, mirrored extent
          Mirror1 "Mirror_1_bei_2_Treibern": of the body so far, about ZX plane of AxisSystem8, deactivated
          Split2 "Split_bei_2_Treibern": SplitPlane ZX plane of AxisSystem3, deactivated
          Mirror2 "Mirror_2_bei_2_Treibern": of the body so far, about ZX plane of AxisSystem3, deactivated
        Remove2 "Remove_Abzug_Treiber": tool Body8
        Pad5 "Pad_Schieberkoerper_Klammer": profile Sketch46, direction (0, 0, -1), length -25 {= - SKb}
        Body9 "Body_1_Schieberkoerper_Hilfsgeometrie_Abzug_Fuehrung"
          Pocket4 "Pocket_Schieberkoerper_Hilfsgeometrie_Abzug_Fuehrung": profile Sketch43, direction (0.766, 0, 0.6428), length 500, mirrored extent
          Body10 "Body_2_Schieberkoerper_Hilfsgeometrie_Abzug_Fuehrung"
            Pad6 "Pad_Schieberkoerper_Hilfsgeometrie_Abzug_Fuehrung": profile Sketch42, direction (-0.766, 0, -0.6428), length 400, mirrored extent
          Remove3 "Remove_2_Schieberkoerper_Hilfsgeometrie_Abzug_Fuehrung": tool Body10
        Remove4 "Remove_1_Schieberkoerper_Hilfsgeometrie_Abzug_Fuehrung": tool Body9
        Body11 "Body_Abzug_Vorlauftreiber"
          Body12 "Body_Hilfskoerper_Abzug_Vorlauftreiber"
            Pad7 "Pad_Abzug_Vorlauftreiber": profile Sketch17, direction (0, -1, 0), length 0 {= Tvb}, mirrored extent, deactivated
            Pad8 "Pad_Abzug_Vorlauftreiber_Schieberweg": profile Extrude1, direction along sketch element, length 21.8548 {= length(sketch element )}, deactivated
          Add3 "Add_Hilfskoerper_Abzug_Vorlauftreiber": tool Body12
          ThickSurface1 "ThickSurface_Abzug_Vorlauftreiber": BotOffset 0, Surface Extract1, TopOffset -3, deactivated
          Thickness1 "Thickness_Abzug_Vorlauftreiber": Thickness 1, deactivated
        Remove5 "Remove_Abzug_Vorlauftreiber": tool Body11
        Body13 "Body_Schieberanschlag"
          SolidCombine1 "Combine_Schieberanschlag": FirstComponentDirection Sketch51, FirstComponentProfile Sketch51, SecondComponentDirection Sketch52, SecondComponentProfile Sketch52
          Body14 "Body_Schieberkoerper_Schieberanschlag_Abzug_Fuehrung"
            Pocket5 "Pocket_Schieberkoerper_Schieberanschlag_Abzug_Fuehrung": profile Sketch42, direction (0.766, 0, 0.6428), length 1000, mirrored extent
            Mirror3 "Mirror_Schieberkoerper_Schieberanschlag_Abzug_Fuehrung": of the body so far, about ZX plane of AxisSystem3
          Remove6 "Remove_Schieberkoerper_Schieberanschlag_Abzug_Fuehrung": tool Body14, deactivated
        Add4 "Add_Schieberanschlag": tool Body13, deactivated
        Chamfer1 "Abschraegung_O-ES-50": length 5, second length 5, on edge [face of Pocket3 from Sketch45.L2 | face of Pad4], deactivated
        Mirror4 "Mirror_Schieberkoerper": of the body so far, about ZX plane of AxisSystem3
        Body15 "Abzug_Montageflaeche"
          Pocket6 "Pocket_Abzug_Montageflaeche": profile Sketch53, direction (0, 0, 1), length 26 {= min(SAd, 30mm) * 1000mm}, mirrored extent
          Thickness2: Thickness 1
        Remove7 "Remove_Abzug_Montageflaeche": tool Body15
        Body16 "Montageflaeche__erlaubter_Bereich_fuer_Anarbeitungen"
          Pad9 "Pad_Montageflaeche": profile Sketch53, direction (0, 0, -1), length -26 {= - Pocket6.FirstLimit.Depth}
          Thickness3: Thickness 1
          Thickness4: Thickness 1
          Body17 "Body_Abzug_Montageflaeche_Profil_KS-OT"
            Pocket7 "Pocket_Abzug_Montageflaeche_Profil_KS-OT": profile CurvePar5, length 1500, mirrored extent, deactivated
          Remove8 "Remove_Abzug_Montageflaeche_Profil_KS-OT": tool Body17, deactivated
        Add5 "Add_Montageflaeche__erlaubter_Bereich_fuer_Anarbeitungen": tool Body16
        Body18 "Body_Gravuren"
          Body19 "Body_Logogravur_1"
            Pocket8 "Pocket_Logogravur": profile Scaling6, length 0.5, mirrored extent
          Add6 "Add_Logogravur_1": tool Body19
          Body20 "Body_Gravur_Identnummer_1"
            Pocket9 "Pocket_Ziffer_1": profile Scaling8, length 0.5, mirrored extent
            Pocket10 "Pocket_Ziffer_2": profile Scaling9, length 0.5, mirrored extent
            Pocket11 "Pocket_Ziffer_3": profile Scaling10, length 0.5, mirrored extent
            Pocket12 "Pocket_Ziffer_4": profile Scaling11, length 0.5, mirrored extent
            Pocket13 "Pocket_Ziffer_5": profile Scaling12, length 0.5, mirrored extent
          Add7 "Add_Gravur_Identnummer_1": tool Body20
          Body21 "Body_Gravur_Bezeichnung_1"
            Pocket14 "Pocket_Letter_1": profile Scaling14, length 0.5, mirrored extent
            Pocket15 "Pocket_Letter_2": profile Scaling15, length 0.5, mirrored extent
            Pocket16 "Pocket_Letter_3": profile Scaling16, length 0.5, mirrored extent
            Pocket17 "Pocket_Letter_4": profile Scaling17, length 0.5, mirrored extent
            Pocket18 "Pocket_Letter_5": profile Scaling18, length 0.5, mirrored extent
            Pocket19 "Pocket_Letter_6": profile Scaling19, length 0.5, mirrored extent
            Pocket20 "Pocket_Letter_7": profile Scaling20, length 0.5, mirrored extent
            Pocket21 "Pocket_Letter_8": profile Scaling21, length 0.5, mirrored extent
            Pocket22 "Pocket_Letter_9": profile Scaling22, length 0.5, mirrored extent
            Pocket23 "Pocket_Letter_10": profile Scaling23, length 0.5, mirrored extent
            Pocket24 "Pocket_Letter_11": profile Scaling24, length 0.5, mirrored extent, deactivated
            Pocket25 "Pocket_Letter_12": profile Scaling25, length 0.5, mirrored extent, deactivated
            Pocket26 "Pocket_Letter_13": profile Scaling26, length 0.5, mirrored extent, deactivated
          Add8 "Add_Gravur_Bezeichnung_1": tool Body21
          Body22 "Body_Logogravur_2"
            Body23 "Copy_of_Body_Logogravur_1"
              Solid1: linked copy from another document
            Add9 "Add_Copy_of_Body_Logogravur_1": tool Body23
            Symmetry1 "Symmetry_1_Logogravur_2": Reference ZX plane of AxisSystem3, ToTransfor Add9
            Symmetry2 "Symmetry_2_Logogravur_2": Reference Plane24, ToTransfor Symmetry1
          Add10 "Add_Logogravur_2": tool Body22
          Body24 "Body_Gravur_Identnummer_2"
            Body25 "Copy_of_Body_Gravur_Identnummer_1"
              Solid2: linked copy from another document
            Add11 "Add_Copy_of_Body_Gravur_Identnummer_1": tool Body25
            Symmetry3 "Symmetry_1_Gravur_Identnummer_2": Reference ZX plane of AxisSystem3, ToTransfor Add11
            Symmetry4 "Symmetry_2_Gravur_Identnummer_2": Reference Plane25, ToTransfor Symmetry3
          Add12 "Add_Gravur_Identnummer_2": tool Body24
          Body26 "Body_Gravur_Bezeichnung_2"
            Body27 "Copy_of_Body_Gravur_Bezeichnung_1"
              Solid3: linked copy from another document
            Add13 "Add_Copy_of_Body_Gravur_Bezeichnung_1": tool Body27
            Symmetry5 "Symmetry_1_Gravur_Bezeichnung_2": Reference ZX plane of AxisSystem3, ToTransfor Add13
            Symmetry6 "Symmetry_2_Gravur_Bezeichnung_2": Reference Plane26, ToTransfor Symmetry5
          Add14 "Add_Gravur_Bezeichnung_2": tool Body26
        Remove9 "Remove_Gravuren": tool Body18
        Sketch71 on Plane10, origin (-11136.9156, 30, -7159.1396), H (0.9876, 0, 0.1571), V (0.1571, 0, -0.9876)
          point P1 (12125.0893, -5330.0715)
          reference projected point E1 (12125.0893, -5330.0715) from sketch element
          coincidence: E1 P1
        Hole1 "Hole_Nullbohrung": placed by Sketch71, at (0, 30, 10) direction (0, -1, 0), diameter 6 {= Nullbohrung_D}, depth 15, V-bottom angle 120
        Mirror5 "Mirror_Nullbohrung": of Hole1, about ZX plane of AxisSystem3
        Sketch72 on Plane10, origin (-11155.4169, 30, -7135.5239), H (0.9876, 0, 0.1571), V (0.1571, 0, -0.9876)
          point P1 (12138.0785, -5293.9662)
          reference projected point E1 (12138.0785, -5293.9662) from sketch element
          coincidence: E1 P1
        Hole2 "Hole_Transportgewinde": placed by Sketch72, at (75, 80, 30) direction (0, -1, 0), diameter 1, depth 25, V-bottom angle 120, deactivated
        Mirror6 "Mirror_Transportgewinde": of Hole2, about ZX plane of AxisSystem3, deactivated
        Body28 "Body_Nullbohrungen_Vertikal_KS-OT"
          Sketch73 on Plane12, origin (-59.5, 943.9491, 2832.5632), H (0, 0.9971, 0.0757), V (0, -0.0757, 0.9971)
            point P1 (-1154.8919, -2743.0143)
            reference projected point E1 (-1154.8919, -2743.0143) from sketch element
            coincidence: E1 P1
          Hole3 "Hole_Nullbohrunge_Vertikal_KS-OT_oben": placed by Sketch73, at (-110, 0, 28) direction (1, 0, 0), diameter 6 {= Nullbohrung_D}, up to Plane13, V-bottom angle 120, deactivated
          Sketch74 on Plane14, origin (39, 1213.7864, 2084.9004), H (0, -0.9971, -0.0757), V (0, -0.0757, 0.9971)
            point P1 (1367.3615, -1977.0715)
            reference projected point E1 (1367.3615, -1977.0715) from sketch element
            coincidence: E1 P1
          Hole4 "Hole_Nullbohrunge_Vertikal_KS-OT_unten": placed by Sketch74, at (140, 0, 28) direction (-1, 0, 0), diameter 6 {= Nullbohrung_D}, up to Plane15, V-bottom angle 120, deactivated
        Remove10 "Remove_Nullbohrungen_Vertikal_KS-OT": tool Body28, deactivated
      Add15 "SCHIEBERKOERPER_WERKZEUG_GESCHLOSSEN": tool Body4
    Add16 "Grundkoerper": tool Body3
    Body29 "Gusskorrektur_Abzug"
    Remove11 "Gusskorrektur_Abzug": tool Body29
    Body30 "Gusskorrektur_Anguss"
    Add17 "Gusskorrektur_Anguss": tool Body30
    Body31 "Gusskorrektur_Freiguss"
    Remove12 "Gusskorrektur_Freiguss": tool Body31
    Body32 "Bearbeitungszugaben"
    Add18 "Bearbeitungszugaben": tool Body32, deactivated
  Add19 "Rohteil": tool Body2
  Body33 "Fraesbearbeitung"
  Remove13 "Fraesbearbeitung": tool Body33
  Body34 "Bohrbearbeitung"
  Remove14 "Bohrbearbeitung": tool Body34
  Body35 "ZSB_Bearbeitung"
  Remove15 "ZSB_Bearbeitung": tool Body35
Body36 "SCHIEBERBETT_Fertigteil"
  Pad10 "Pad_Schieberbett_Profil": profile Sketch21, direction (0, 1, 0), length 25 {= Bb - B22}
  Pad11 "Pad_Schieberbett_Flansch": profile Sketch24, direction (-1, 0, 0), up to Plane5
  Body37 "Body_Schieberbett_Hilfsgeometrie_Abzug_Profil"
    Pocket27 "Pocket_Schieberbett_Hilfsgeometrie_Abzug_Profil": profile Sketch22, direction (0, -1, 0), length 500, mirrored extent
    Pad12 "Pad_Schieberbett_Hilfsgeometrie_Abzug_Profil": profile Sketch21, direction (0, 1, 0), length 600, mirrored extent
  Remove16 "Remove_Schieberbett_Hilfsgeometrie_Abzug_Profil": tool Body37
  Body38 "Body_Schieberbett_Fuehrungsklammer"
    Pad13 "Pad_Schieberbett_Fuehrungsklammer": profile Sketch23, direction (0, 1, 0), length 15.5 {= Bb - Bkd}, opposite side length -30 {= -Bb}
    Translate24 "Translate_1_Korrektur_Fuehrungsklammer_bei_O-ES-50": Direction edge [YZ plane of AxisSystem4 | XY plane of AxisSystem4], ToTransfor Pad13, Length 1
  Add20 "Add_Schieberbett_Fuehrungsklammer": tool Body38
  Split3 "Split_Sohle": SplitPlane XY plane of AxisSystem4
  Split4 "Split_Schulter": SplitPlane YZ plane of AxisSystem4
  Body39 "Body_Schieberbett_Abzug_Flansch"
    Pocket28 "Pocket_Schieberbett_Abzug_Flansch": profile Sketch25, direction (-1, 0, 0), length -500
  Remove17 "Remove_Schieberbett_Abzug_Flansch": tool Body39
  Body40 "Body_Gravur_Schieberdiagramm"
    Pocket29 "Diagrammgravur": profile Scaling2, length 0.5, mirrored extent
    Translate25 "Translate_2_Korrektur_Fuehrungsklammer_bei_O-ES-50": Direction edge [YZ plane of AxisSystem4 | XY plane of AxisSystem4], ToTransfor Pocket29, Length 1
  Remove18 "Remove_Gravur_Schieberdiagramm": tool Body40
  Mirror7 "Mirror_Schieberbett": of the body so far, about ZX plane of AxisSystem4
  Body41 "Body_Diagrammgravur_Text"
    Body42 "Body_Diagrammgravur_Text_1"
      Pocket30 "Diagrammgravur_Text": profile Scaling4, length 0.5, mirrored extent
      Pocket31 "Diagrammgravur_Text_Scale": profile Scaling5, length 0.5, mirrored extent, deactivated
      Translate26 "Translate_3_Korrektur_Fuehrungsklammer_bei_O-ES-50": Direction edge [YZ plane of AxisSystem4 | XY plane of AxisSystem4], ToTransfor Pocket31, Length 1
    Add21 "Add_Diagrammgravur_Text_1": tool Body42
    Body43 "Body_Diagrammgravur_Text_2"
      Body44 "Copy_of_Body_Diagrammgravur_Text_1"
        Solid4: linked copy from another document
      Add22 "Add_Copy_of_Body_Diagrammgravur_Text_1": tool Body44
      Symmetry7 "Symmetry_1_Diagrammgravur_Text_2": Reference ZX plane of AxisSystem4, ToTransfor Add22
      Symmetry8 "Symmetry_2_Diagrammgravur_Text_2": Reference Plane22, ToTransfor Symmetry7
    Add23 "Add_Diagrammgravur_Text_2": tool Body43
  Remove19 "Remove_Diagrammgravur_Text": tool Body41
  Body45 "Body_Abzug_Treiber_Grundgeometrie"
    SolidCombine2 "Combine_Abzug_Treiber_Grundgeometrie": FirstComponentDirection Near1, FirstComponentProfile Near1, SecondComponentDirection Near2, SecondComponentProfile Near2
    Body46 "Body_1_Abzug_Treiber_Grundgeometrie"
      Pocket32 "Pocket_1_Abzug_Treiber_Grundgeometrie": profile Near3, length 700, mirrored extent
    Remove20 "Remove_1_Abzug_Treiber_Grundgeometrie": tool Body46
    Pocket33 "Pocket_2_Abzug_Treiber_Grundgeometrie": profile Near4, length 1500, mirrored extent
    Mirror8 "Mirror_Abzug_Treiber_Grundgeometrie": of the body so far, about ZX plane of AxisSystem8
    Mirror9 "Mirror_Abzug_Treiber_Grundgeometrie_KS-OT": of the body so far, about ZX plane of AxisSystem4, deactivated
  Remove21 "Remove_Abzug_Treiber_Grundgeometrie --- Variante 1": tool Body45
  Body47 "Body_Schieberbett_Abzug_Schieberanschlag"
    SolidCombine3 "Combine_Schieberbett_Abzug_Schieberanschlag": FirstComponentDirection Sketch51, FirstComponentProfile Sketch51, SecondComponentDirection Sketch52, SecondComponentProfile Sketch52
    Thickness5 "Thickness_Schieberbett_Abzug_Schieberanschlag": Thickness 1
    Mirror10 "Mirror_Schieberbett_Abzug_Schieberanschlag": of the body so far, about ZX plane of AxisSystem4
  Remove22 "Remove_Schieberbett_Abzug_Schieberanschlag": tool Body47, deactivated
  Pad14 "Passfeder_1": profile Sketch33, direction (1, 0, 0), length 9, mirrored extent
  Mirror11 "Passfeder_1_Mirr": of Pad14, about ZX plane of AxisSystem4, deactivated
  Pad15 "Passfeder_2": profile Sketch34, direction (1, 0, 0), length 1, mirrored extent, deactivated
  Mirror12 "Passfeder_2_Mirr": of Pad15, about ZX plane of AxisSystem4, deactivated
  Pad16 "Passfeder_3": profile Sketch35, direction (1, 0, 0), length 1, mirrored extent, deactivated
  Mirror13 "Passfeder_3_Mirr": of Pad16, about ZX plane of AxisSystem4, deactivated
  Body48 "Body_Schieberbett_Profil_Fuehrung"
    Pocket34 "Pocket_Schieberbett_Profil_Fuehrung": profile Sketch42, direction (0.766, 0, 0.6428), length 113.5 {= S1 + Gasdruckfederweg}, opposite side length 2
    Mirror14 "Mirror_Schieberbett_Profil_Fuehrung": of the body so far, about ZX plane of AxisSystem4
  Remove23 "Remove_Schieberbett_Profil_Fuehrung": tool Body48
  Sketch75 on Plane6, origin (385, 18188.9301, -12083.9213), H (0, 0.8025, -0.5966), V (0, 0.5966, 0.8025)
    point P1 (-21882.5686, -1023.407)
    reference projected point E1 (-21882.5686, -1023.407) from sketch element
    coincidence: E1 P1
  Hole5 "Schraubenbohrung_Bs1": placed by Sketch75, at (385, 17.5, 151) direction (-1, 0, 0), diameter 11, depth 500 {= Plane6.Offset}, V-bottom angle 120, counterbore diameter 18, counterbore depth 476
  Mirror15 "Schraubenbohrung_Bs1_Mirr": of Hole5, about ZX plane of AxisSystem4
  Sketch76 on Plane6, origin (385, 18205.732, -12039.0087), H (0, 0.8025, -0.5966), V (0, 0.5966, 0.8025)
    point P1 (-21767.8249, -1205.8997)
    reference projected point E1 (-21767.8249, -1205.8997) from sketch element
    coincidence: E1 P1
  Hole6 "Schraubenbohrung_Bs2": placed by Sketch76, at (385, 17.5, -19) direction (-1, 0, 0), diameter 11, depth 500 {= Plane6.Offset}, V-bottom angle 120, counterbore diameter 18, counterbore depth 476
  Mirror16 "Schraubenbohrung_Bs2_Mirr": of Hole6, about ZX plane of AxisSystem4
  Sketch77 on Plane6, origin (385, 18205.732, -12039.0087), H (0, 0.8025, -0.5966), V (0, 0.5966, 0.8025)
    point P1 (-21890.2529, -1068.8865)
    reference projected point E1 (-21890.2529, -1068.8865) from sketch element
    coincidence: E1 P1
  Hole7 "Schraubenbohrung_Bs3": placed by Sketch77, at (377.2138, 45, 181.7365) direction (-0.9063, 0, 0.4226), diameter 1, depth 500 {= Plane6.Offset}, V-bottom angle 120, counterbore diameter 1, counterbore depth 499, deactivated
  Mirror17 "Schraubenbohrung_Bs3_Mirr": of Hole7, about ZX plane of AxisSystem4, deactivated
  Sketch78 on Plane6, origin (385, 18205.732, -12039.0087), H (0, 0.8025, -0.5966), V (0, 0.5966, 0.8025)
    point P1 (-21890.2529, -1068.8865)
    reference projected point E1 (-21890.2529, -1068.8865) from sketch element
    coincidence: E1 P1
  Hole8 "Schraubenbohrung_Bs4": placed by Sketch78, at (377.2138, 140, 181.7365) direction (-0.9063, 0, 0.4226), diameter 1, depth 500 {= Plane6.Offset}, V-bottom angle 120, counterbore diameter 1, counterbore depth 499, deactivated
  Mirror18 "Schraubenbohrung_Bs4_Mirr": of Hole8, about ZX plane of AxisSystem4, deactivated
  Sketch79 on Plane6, origin (385, 18205.732, -12039.0087), H (0, 0.8025, -0.5966), V (0, 0.5966, 0.8025)
    point P1 (-21890.2529, -1068.8865)
    reference projected point E1 (-21890.2529, -1068.8865) from sketch element
    coincidence: E1 P1
  Hole9 "Schraubenbohrung_Bs5": placed by Sketch79, at (295, 320, 323) direction (-1, 0, 0), diameter 1, depth 500 {= Plane6.Offset}, V-bottom angle 120, counterbore diameter 1, counterbore depth 499, deactivated
  Mirror19 "Schraubenbohrung_Bs5_Mirr": of Hole9, about ZX plane of AxisSystem4, deactivated
  Sketch80 on Plane6, origin (385, 18205.732, -12039.0087), H (0, 0.8025, -0.5966), V (0, 0.5966, 0.8025)
    point P1 (-21890.2529, -1068.8865)
    reference projected point E1 (-21890.2529, -1068.8865) from sketch element
    coincidence: E1 P1
  Hole10 "Schraubenbohrung_Bs6": placed by Sketch80, at (295, 480, 323) direction (-1, 0, 0), diameter 1, depth 500 {= Plane6.Offset}, V-bottom angle 120, counterbore diameter 1, counterbore depth 499, deactivated
  Mirror20 "Schraubenbohrung_Bs6_Mirr": of Hole10, about ZX plane of AxisSystem4, deactivated
  Body49 "Body_Stiftbohrung_Bp1"
    Sketch81 on Plane6, origin (385, 18205.732, -12039.0087), H (0, 0.8025, -0.5966), V (0, 0.5966, 0.8025)
      point P1 (-21883.299, -1079.9157)
      reference projected point E1 (-21883.299, -1079.9157) from sketch element
      coincidence: E1 P1
    Hole11 "Stiftbohrung_Bp1": placed by Sketch81, at (385, 0, 151) direction (-1, 0, 0), diameter 10, depth 500 {= Plane6.Offset}, V-bottom angle 120, counterbore diameter 11, counterbore depth 460
    Symmetry9 "Stiftbohrung_Bp1_Symmetry": Reference ZX plane of AxisSystem4, ToTransfor Hole11
    Mirror21 "Stiftbohrung_Bp1_Mirr": of Hole11, about ZX plane of AxisSystem4, deactivated
  Remove24 "Remove_Stiftbohrung_Bp1": tool Body49
  Body50 "Body_Stiftbohrung_Bp2"
    Sketch82 on Plane6, origin (385, 18205.732, -12039.0087), H (0, 0.8025, -0.5966), V (0, 0.5966, 0.8025)
      point P1 (-21783.062, -1214.7361)
      reference projected point E1 (-21783.062, -1214.7361) from sketch element
      coincidence: E1 P1
    Hole12 "Stiftbohrung_Bp2": placed by Sketch82, at (385, 0, -17) direction (-1, 0, 0), diameter 10, depth 500 {= Plane6.Offset}, V-bottom angle 120, counterbore diameter 11, counterbore depth 460
    Symmetry10 "Stiftbohrung_Bp2_Symmetry": Reference ZX plane of AxisSystem4, ToTransfor Hole12
    Mirror22 "Stiftbohrung_Bp2_Mirr": of Hole12, about ZX plane of AxisSystem4, deactivated
  Remove25 "Remove_Stiftbohrung_Bp2": tool Body50