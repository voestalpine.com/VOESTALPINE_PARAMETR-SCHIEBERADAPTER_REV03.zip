# CATIA V5 part "VOESTALPINE_PARAMETR-SCHIEBERADAPTER_REV03.CATPart"
## Design history (mm, degrees; sets first, then bodies; in a sketch O, H, V are its origin and axes)
(part 4 of 4)
Body51 "TREIBER_Fertigteil"
  Body52 "Treibergeometrie"
    Body53 "Body_Treiber_Grundgeometrie"
      SolidCombine4 "Combine_Treiber_Grundgeometrie": FirstComponentDirection Sketch2, FirstComponentProfile Sketch2, SecondComponentDirection Sketch3, SecondComponentProfile Sketch3
      Body54 "Body_Treiber_Abzug_Vorderansicht"
        Pocket35 "Pocket_Treiber_Abzug_Vorderansicht": profile Sketch4, direction (0, 0, 1), length 500, mirrored extent
      Remove26 "Remove_Treiber_Abzug_Vorderansicht": tool Body54
      Pocket36 "Pocket_Treiber_Abzug_Treiberflaeche": profile Sketch5, direction (0, 0, 1), length 500, mirrored extent
      Pocket37 "Pocket_Treiber_Abzug_Flansch": profile Sketch6, direction (1, 0, 0), up to Plane2
      Split5 "Split_Treiber_Hoehe_Dh": SplitPlane Plane3, deactivated
      Body55 "Body_Treiber_Abzug_Arbeitsflaeche_Unterkante"
        Pocket38 "Pocket_Treiber_Abzug_Arbeitsflaeche_Unterkante": profile Sketch14, direction (0, 0, 1), length 400, mirrored extent
        Pad17 "Pad_1_Treiber_Abzug_Arbeitsflaeche_Unterkante": profile Sketch44, direction (0, 0, -1), length 500, mirrored extent
        Pad18 "Pad_2_Treiber_Abzug_Arbeitsflaeche_Unterkante": profile Translate1, length 500, mirrored extent
      Remove27 "Remove_Treiber_Abzug_Arbeitsflaeche_Unterkante": tool Body55
      Body56 "Body_Treiber_Abzug_Zwangsrueckzug"
        Pocket39 "Pocket_Treiber_Abzug_Zwangsrueckzug": profile Sketch15, direction (0, -1, 0), length 80 {= Tfb +50mm}, opposite side length -16 {= - ((SKl2 - SKh2 - 1mm) - Abstand_Treiber )}
        Body57 "Body_Treiber_Korrektur_Abzug_Zwangsrueckzug"
          Pad19 "Pad_Treiber_Korrektur_Abzug_Zwangsrueckzug": profile Sketch3, direction (-1, 0, 0), up to Plane1
        Remove28 "Remove_Treiber_Korrektur_Abzug_Zwangsrueckzug": tool Body57
        Body58 "Body_Treiber_Abzug_Klammer"
          Pocket40 "Pocket_Treiber_Abzug_Klammer": profile Sketch16, direction (0, -1, 0), length 80 {= Tfb +50mm}, opposite side length -16 {= - ((SKl2 - SKh2 - 1mm) - Abstand_Treiber)}
        Add24 "Add_Treiber_Abzug_Klammer": tool Body58
        Body59 "Body_Treiber_Abzug_Klammer_2"
          Pocket41 "Pocket_Treiber_Abzug_Klammer_2": profile Sketch46, direction (0, 0, 1), length 70, opposite side length 1
          Thickness6 "Thickness_Treiber_Abzug_Klammer_2": Thickness 1
        Add25 "Add_Treiber_Abzug_Klammer_2": tool Body59
      Remove29 "Remove_Treiber_Abzug_Zwangsrueckzug": tool Body56
      Body60 "Body_Vorlauftreiber"
        Pad20 "Pad_Vorlauftreiber": profile Sketch17, direction (0, -1, 0), length 0 {= Tvb}, deactivated
        Body61 "Body_Treiber_Vorlauftreiber_Hilfsgeometrie_Solidabzug"
          Pocket42 "Pocket_Treiber_Vorlauftreiber_Hilfsgeometrie_Solidabzug": profile Sketch18, direction (0, 1, 0), length 800, mirrored extent, deactivated
        Remove30 "Remove_Treiber_Vorlauftreiber_Hilfsgeometrie_Solidabzug": tool Body61, deactivated
      Add26 "Add_Vorlauftreiber": tool Body60
      Body62 "Body_Sonderflansch_O-ES-50"
        Pad21 "Pad_Sonderflansch_O-ES-50": profile Sketch3, direction (-1, 0, 0), length 18
        Translate27 "Translate_Sonderflansch_O-ES-50": Direction edge [XY plane of AxisSystem5 | ZX plane of AxisSystem5], ToTransfor Pad21, Length 5
      Add27 "Add_Sonderflansch_O-ES-50": tool Body62, deactivated
      Mirror23 "Mirror_Treiber": of the body so far, about ZX plane of AxisSystem8
      Body63 "Body_Treiber_Abzug_Zwangsrueckzug_KS-OT"
        Pocket43 "Pocket_Treiber_Abzug_Zwangsrueckzug_KS-OT": profile Sketch19, direction (0, 0, 1), length 300, mirrored extent, deactivated
      Remove31 "Remove_Treiber_Abzug_Zwangsrueckzug_KS-OT": tool Body63, deactivated
    Add28 "Add_Treiber_Grundgeometrie": tool Body53
    Sketch83 on Plane4, origin (-410, -30993.9284, 20335.2144), H (0, -0.8025, 0.5966), V (0, 0.5966, 0.8025)
      point P1 (-36922.214, 2252.1795)
      reference projected point E1 (-36922.214, 2252.1795) from sketch element
      coincidence: E1 P1
    Hole13 "Schraubenbohrung_Ts1": placed by Sketch83, at (-410, -20, 113) direction (1, 0, 0), diameter 11, depth 500 {= Plane4.Offset}, V-bottom angle 120, counterbore diameter 18, counterbore depth 490
    Mirror24 "Schraubenbohrung_Ts1_Mirr": of Hole13, about ZX plane of AxisSystem8
    Sketch84 on Plane4, origin (-410, -30993.9284, 20335.2144), H (0, -0.8025, 0.5966), V (0, 0.5966, 0.8025)
      point P1 (-36994.9457, 2187.8748)
      reference projected point E1 (-36994.9457, 2187.8748) from sketch element
      coincidence: E1 P1
    Hole14 "Schraubenbohrung_Ts2": placed by Sketch84, at (-410, 0, 18) direction (1, 0, 0), diameter 11, depth 500 {= Plane4.Offset}, V-bottom angle 120, counterbore diameter 18, counterbore depth 490
    Mirror25 "Schraubenbohrung_Ts2_Mirr": of Hole14, about ZX plane of AxisSystem8, deactivated
    Sketch85 on Plane4, origin (-410, -30993.9284, 20335.2144), H (0, -0.8025, 0.5966), V (0, 0.5966, 0.8025)
      point P1 (-36938.264, 2264.1125)
      reference projected point E1 (-36938.264, 2264.1125) from sketch element
      coincidence: E1 P1
    Hole15 "Stiftbohrung_Tp1": placed by Sketch85, at (-410, 0, 113) direction (1, 0, 0), diameter 10, depth 500 {= Plane4.Offset}, V-bottom angle 120, counterbore diameter 11, counterbore depth 470
    Mirror26 "Stiftbohrung_Tp1_Mirr": of Hole15, about ZX plane of AxisSystem8, deactivated
    Sketch86 on Plane4, origin (-410, -30993.9284, 20335.2144), H (0, -0.8025, 0.5966), V (0, 0.5966, 0.8025)
      point P1 (-37003.8954, 2175.8372)
      reference projected point E1 (-37003.8954, 2175.8372) from sketch element
      coincidence: E1 P1
    Hole16 "Stiftbohrung_Tp2": placed by Sketch86, at (-410, 0, 3) direction (1, 0, 0), diameter 10, depth 500 {= Plane4.Offset}, V-bottom angle 120, counterbore diameter 11, counterbore depth 470
    Mirror27 "Stiftbohrung_Tp2_Mirr": of Hole16, about ZX plane of AxisSystem8, deactivated
  Add29 "Add_Treibergeometrie": tool Body52
  Mirror28 "Mirror_Spiegelung_Treibergeometrie_bei_2_Treibern": of the body so far, about ZX plane of AxisSystem5, deactivated
Body64 "SCHIEBERBETT_Gussteil01_Anguss"
  Pad22 "Pad_Schieberbett_Anguss": profile Sketch28, direction (1, 0, 0), length 10, opposite side length 50 {= FP__Schieberbett_Hoehe_Anguss}
  Pad23 "Pad_Schieberbett_Anguss_Schulterung": profile Sketch29, direction (1, 0, 0), length 145, opposite side length 50 {= FP__Schieberbett_Hoehe_Anguss}
  Pocket44 "Pocket_Schieberbett_Freiguss_Schulterung": profile Sketch30, direction (0, -1, 0), length 800, mirrored extent, deactivated
Body65 "SCHIEBERBETT_Gussteil01_Fraesbearbeitung"
  Pocket45 "Pocket_Schieberbett_Fraesbearbeitung_1": profile Sketch31, direction (-1, 0, 0), length -400
  Pocket46 "Pocket_Schieberbett_Fraesbearbeitung_2": profile Sketch32, direction (-1, 0, 0), length -400
Body66 "SCHIEBERBETT_Gussteil01_Fraesbearbeitung_Passfeder"
  Sketch87 "Sketch_Dummy" on XY plane of AxisSystem4, origin (-115, 0, 165), H (0, 0, -1), V (0, 1, 0)
    line L1 (0, -0.5) -> (0, 0.5)
    line L2 (0, 0.5) -> (1, 0.5)
    line L3 (1, 0.5) -> (1, -0.5)
    line L4 (1, -0.5) -> (0, -0.5)
    distance L2 L4 = 1
    distance L3 L1 = 1
    vertical: L1 V, L3 V
    horizontal: L2 H, L4 H
    coincidence: V L1
    symmetry: L2 L4 H
  Pocket47 "Dummy": profile Sketch87, direction (-1, 0, 0), length -1
  Body67 "Passfeder_Fraesbearbeitung"
    Pocket48 "Pocket_Schieberbett_Passfeder_Fraesbearbeitung_1": profile Sketch36, direction (-1, 0, 0), length 12, mirrored extent
    Mirror29 "Pocket_Schieberbett_Passfeder_Fraesbearbeitung_1_Mirr": of Pocket48, about ZX plane of AxisSystem4, deactivated
    Pocket49 "Pocket_Schieberbett_Passfeder_Fraesbearbeitung_2": profile Sketch37, direction (-1, 0, 0), length 12, mirrored extent, deactivated
    Mirror30 "Pocket_Schieberbett_Passfeder_Fraesbearbeitung_2_Mirr": of Pocket49, about ZX plane of AxisSystem4, deactivated
    Pocket50 "Pocket_Schieberbett_Passfeder_Fraesbearbeitung_3": profile Sketch38, direction (-1, 0, 0), length 12, mirrored extent, deactivated
    Mirror31 "Pocket_Schieberbett_Passfeder_Fraesbearbeitung_3_Mirr": of Pocket50, about ZX plane of AxisSystem4, deactivated
  Add30 "Add_Passfeder_Fraesbearbeitung": tool Body67, deactivated
Body68 "SCHIEBERBETT_Gussteil01_Bohrbearbeitung_Gewinde"
  Sketch88 on Plane36, origin (-115, 0, 165), H (0, 0, -1), V (0, 1, 0)
    point P1 (14, 17.5)
    reference projected point E1 (14, 17.5) from sketch element
    coincidence: E1 P1
  Hole17 "Gewinde_Bs1": placed by Sketch88, at (-115, 17.5, 151) direction (-1, 0, 0), diameter 8.376, depth 26.8, V-bottom angle 120, threaded "M10", thread diameter 10, thread depth 19.5, pitch 1.5
  Mirror32 "Gewinde_Bs1_Mirr": of Hole17, about ZX plane of AxisSystem4
  Sketch89 on Plane36, origin (-115, 0, 165), H (0, 0, -1), V (0, 1, 0)
    point P1 (184, 17.5)
    reference projected point E1 (184, 17.5) from sketch element
    coincidence: E1 P1
  Hole18 "Gewinde_Bs2": placed by Sketch89, at (-115, 17.5, -19) direction (-1, 0, 0), diameter 8.376, depth 26.8, V-bottom angle 120, threaded "M10", thread diameter 10, thread depth 19.5, pitch 1.5
  Mirror33 "Gewinde_Bs2_Mirr": of Hole18, about ZX plane of AxisSystem4
  Sketch90 on Plane36, origin (-115, 0, 165), H (0, 0, -1), V (0, 1, 0)
    point P1 (1, 1)
    reference projected point E1 (1, 1) from sketch element
    coincidence: E1 P1
  Hole19 "Gewinde_Bs3": placed by Sketch90, at (-75.9401, 45, 393.0456) direction (-0.9063, 0, 0.4226), diameter 0, depth 7.3, V-bottom angle 120, threaded "M0", thread diameter 0, thread depth 0, pitch 0, deactivated
  Mirror34 "Gewinde_Bs3_Mirr": of Hole19, about ZX plane of AxisSystem4, deactivated
  Sketch91 on Plane36, origin (-115, 0, 165), H (0, 0, -1), V (0, 1, 0)
    point P1 (1, 1)
    reference projected point E1 (1, 1) from sketch element
    coincidence: E1 P1
  Hole20 "Gewinde_Bs4": placed by Sketch91, at (-75.9401, 140, 393.0456) direction (-0.9063, 0, 0.4226), diameter 0, depth 7.3, V-bottom angle 120, threaded "M0", thread diameter 0, thread depth 0, pitch 0, deactivated
  Mirror35 "Gewinde_Bs4_Mirr": of Hole20, about ZX plane of AxisSystem4, deactivated
  Sketch92 on Plane36, origin (-115, 0, 165), H (0, 0, -1), V (0, 1, 0)
    point P1 (1, 1)
    reference projected point E1 (1, 1) from sketch element
    coincidence: E1 P1
  Hole21 "Gewinde_Bs5": placed by Sketch92, at (-205, 320, 323) direction (-1, 0, 0), diameter 0, depth 7.3, V-bottom angle 120, threaded "M0", thread diameter 0, thread depth 0, pitch 0, deactivated
  Mirror36 "Gewinde_Bs5_Mirr": of Hole21, about ZX plane of AxisSystem4, deactivated
  Sketch93 on Plane36, origin (-115, 0, 165), H (0, 0, -1), V (0, 1, 0)
    point P1 (1, 1)
    reference projected point E1 (1, 1) from sketch element
    coincidence: E1 P1
  Hole22 "Gewinde_Bs6": placed by Sketch93, at (-205, 480, 323) direction (-1, 0, 0), diameter 0, depth 7.3, V-bottom angle 120, threaded "M0", thread diameter 0, thread depth 0, pitch 0, deactivated
  Mirror37 "Gewinde_Bs6_Mirr": of Hole22, about ZX plane of AxisSystem4, deactivated
Body69 "SCHIEBERBETT_Gussteil01_Bohrbearbeitung_Stifte"
  Body70 "Body_Stiftpassung_Bp1"
    Sketch94 on Plane36, origin (-115, 0, 165), H (0, 0, -1), V (0, 1, 0)
      point P1 (14, 0)
      reference projected point E1 (14, 0) from sketch element
      coincidence: E1 P1
    Hole23 "Stiftpassung_Bp1": placed by Sketch94, at (-115, 0, 151) direction (-1, 0, 0), diameter 10, depth 25, V-bottom angle 120
    Symmetry11 "Stiftpassung_Bp1_Symmetry": Reference ZX plane of AxisSystem4, ToTransfor Hole23
    Mirror38 "Stiftpassung_Bp1_Mirr": of Hole23, about ZX plane of AxisSystem4, deactivated
  Add31 "Add_Stiftpassung_Bp1": tool Body70
  Body71 "Body_Stiftpassung_Bp2"
    Sketch95 on Plane36, origin (-115, 0, 165), H (0, 0, -1), V (0, 1, 0)
      point P1 (182, 0)
      reference projected point E1 (182, 0) from sketch element
      coincidence: E1 P1
    Hole24 "Stiftpassung_Bp2": placed by Sketch95, at (-115, 0, -17) direction (-1, 0, 0), diameter 10, depth 25, V-bottom angle 120
    Symmetry12 "Stiftpassung_Bp2_Symmetry": Reference ZX plane of AxisSystem4, ToTransfor Hole24
    Mirror39 "Stiftpassung_Bp2_Mirr": of Hole24, about ZX plane of AxisSystem4, deactivated
  Add32 "Add_Stiftpassung_Bp2": tool Body71
Body72 "TREIBER_Gussteil02_Anguss"
  Pad24 "Pad_Treiber_Anguss": profile Sketch9, direction (-1, 0, 0), length 10, opposite side length 50 {= FP__Treiber_Hoehe_Anguss}
  Pad25 "Pad_Treiber_Anguss_Schulterung": profile Sketch10, direction (-1, 0, 0), length 26, opposite side length 50 {= FP__Treiber_Hoehe_Anguss}
  Pocket51 "Pocket_Treiber_Freiguss_Schulterung": profile Sketch11, direction (0, 1, 0), length 800, mirrored extent, deactivated
  Mirror40 "Mirror_Spiegelung_Treiberanguss_bei_2_Treibern": of the body so far, about ZX plane of AxisSystem5, deactivated
Body73 "TREIBER_Gussteil02_Fraesbearbeitung"
  Pocket52 "Pocket_Treiber_Fraesbearbeitung_1": profile Sketch12, direction (1, 0, 0), length -400
  Mirror41 "Mirror_Spiegelung_Treiber_Fraesbearbeitung_1_bei_2_Treibern": of Pocket52, about ZX plane of AxisSystem5, deactivated
  Body74 "Body_Treiber_Fraesbearbeitung_2"
    Pocket53 "Pocket_Treiber_Fraesbearbeitung_2": profile Sketch13, direction (1, 0, 0), length -400
    Mirror42 "Mirror_Spiegelung_Treiber_Fraesbearbeitung_2_bei_2_Treibern": of Pocket53, about ZX plane of AxisSystem5, deactivated
  Add33 "Add_Treiber_Fraesbearbeitung_2": tool Body74
Body75 "TREIBER_Gussteil02_Bohrbearbeitung_Gewinde"
  Sketch96 on Plane37, origin (90, 0, 125), H (0, 0, -1), V (0, -1, 0)
    point P1 (12, 20)
    reference projected point E1 (12, 20) from sketch element
    coincidence: E1 P1
  Hole25 "Gewinde_Ts1": placed by Sketch96, at (90, -20, 113) direction (1, 0, 0), diameter 8.376, depth 26.8, V-bottom angle 120, threaded "M10", thread diameter 10, thread depth 19.5, pitch 1.5
  Mirror43 "Gewinde_Ts1_Mirr": of Hole25, about ZX plane of AxisSystem8
  Sketch97 on Plane37, origin (90, 0, 125), H (0, 0, -1), V (0, -1, 0)
    point P1 (107, 0)
    reference projected point E1 (107, 0) from sketch element
    coincidence: E1 P1
  Hole26 "Gewinde_Ts2": placed by Sketch97, at (90, 0, 18) direction (1, 0, 0), diameter 8.376, depth 26.8, V-bottom angle 120, threaded "M10", thread diameter 10, thread depth 19.5, pitch 1.5
  Mirror44 "Gewinde_Ts2_Mirr": of Hole26, about ZX plane of AxisSystem8, deactivated
  Mirror45 "Mirror_Spiegelung_Gewinde_bei_2_Treibern": of the body so far, about ZX plane of AxisSystem5, deactivated
Body76 "TREIBER_Gussteil02_Bohrbearbeitung_Stifte"
  Sketch98 on Plane37, origin (90, 0, 125), H (0, 0, -1), V (0, -1, 0)
    point P1 (12, 0)
    reference projected point E1 (12, 0) from sketch element
    coincidence: E1 P1
  Hole27 "Stiftpassung_Tp1": placed by Sketch98, at (90, 0, 113) direction (1, 0, 0), diameter 10, depth 25, V-bottom angle 120
  Mirror46 "Stiftpassung_Tp1_Mirr": of Hole27, about ZX plane of AxisSystem8, deactivated
  Sketch99 on Plane37, origin (90, 0, 125), H (0, 0, -1), V (0, -1, 0)
    point P1 (122, 0)
    reference projected point E1 (122, 0) from sketch element
    coincidence: E1 P1
  Hole28 "Stiftpassung_Tp2": placed by Sketch99, at (90, 0, 3) direction (1, 0, 0), diameter 10, depth 25, V-bottom angle 120
  Mirror47 "Stiftpassung_Tp2_Mirr": of Hole28, about ZX plane of AxisSystem8, deactivated
  Mirror48 "Mirror_Spiegelung_Gewinde_bei_2_Treibern": of the body so far, about ZX plane of AxisSystem5, deactivated
Body77 "SCHIEBER_Montagefreiraum"
  Body78 "FIXING_SPACE_CAM_SLIDER_GAS_SPRING"
    Pad26 "Pad_GDF1": profile Sketch55, direction (0.766, 0, 0.6428), length -106
    Mirror49 "Mirr_GDF1": of Pad26, about ZX plane of AxisSystem3, deactivated
    Pad27 "Pad_GDF2": profile Sketch56, direction (0.766, 0, 0.6428), length -1, deactivated
    Mirror50 "Mirr_GDF2": of Pad27, about ZX plane of AxisSystem3, deactivated
    Pad28 "Pad_Mittelfuehrung": profile Sketch57, direction (0.766, 0, 0.6428), length -1, deactivated
    Mirror51 "Mirr_Mittelfuehrung": of Pad28, about ZX plane of AxisSystem3, deactivated
  Add34 "Add_FIXING_SPACE_CAM_SLIDER_GAS_SPRING": tool Body78
  Body79 "FIXING_SPACE_CAM_BASE"
    Body80 "CopyBody_Schieberbett_Fuehrungsklammer"
      Solid5: linked copy from another document
    Add35 "Add_CopyBody_Schieberbett_Fuehrungsklammer": tool Body80
    Translate28 "Translate_Fuehrungsklammer": Direction edge [YZ plane of AxisSystem4 | XY plane of AxisSystem4], ToTransfor Add35, Length 29 {= Bkd *2}
    Mirror52 "Mirror_Fuehrungsklammer": of the body so far, about ZX plane of AxisSystem4
  Add36 "Add_FIXING_SPACE_CAM_BASE": tool Body79
  Body81 "FIXING_SPACE_CAM_SLIDER"
    Body82 "CopyBody_SCHIEBERKOERPER"
      Solid6: linked copy from another document
    Add37 "Add_CopyBody_SCHIEBERKOERPER": tool Body82
    Translate29 "Translate_SCHIEBERKOERPER": ToTransfor Add37, FirstPoint Project2, SecondPoint Project3
  Add38 "Add_FIXING_SPACE_CAM_SLIDER": tool Body81
Body83 "SCHIEBER_Bauraum"
  Body84 "Body_Treiber_Bauraum"
    Pad29 "Pad_Treiber_Bauraum": profile Sketch64, direction (0, -1, 0), length 30 {= Treiber_Absolutmass_Y}, mirrored extent
  Add39 "Add_Treiber_Bauraum": tool Body84
  Body85 "Body_Schieberbett_Bauraum"
    Pad30 "Pad_Schieberbett_Bauraum": profile Sketch65, direction (0, 1, 0), length 30 {= Schieberbett_Absolutmass_Y}, mirrored extent
  Add40 "Add_Schieberbett_Bauraum": tool Body85
  Body86 "Body_Schieberkoerper_Bauraum"
    Pad31 "Pad_Schieberkoerper_Bauraum": profile Sketch66, direction (0, 1, 0), length 30 {= Schieberkoerper_Absolutmass_Y_Max}, opposite side length 30 {= Schieberkoerper_Absolutmass_Y_Min}
    Split6 "Split_an_Treibersohle": SplitPlane XY plane of AxisSystem5
    Split7 "Split_an_Schieberbettsohle": SplitPlane XY plane of AxisSystem4
  Add41 "Add_Schieberkoerper_Bauraum": tool Body86
Body87 "SCHIEBERSTELLUNG_OFFEN_RELATIV_ZU_SCHIEBERBETT_TREIBER"
  Body88 "Schieberkoerper_Offen"
    Body89 "CopyBody_1_SCHIEBERKOERPER"
      Solid7: linked copy from another document
    Add42 "Add_CopyBody_1_SCHIEBERKOERPER": tool Body89
    Translate30 "Translate_in_Schieberbett_Richtung": Direction sketch element, ToTransfor Add42, Length -34 {= - Gasdruckfederweg}
  Add43 "Add_Schieberkoerper_Offen": tool Body88
  Body90 "Treiber_Stellung_Offen"
    Body91 "CopyBody_1_TREIBER"
      Solid8: linked copy from another document
    Add44 "Add_CopyBody_1_TREIBER": tool Body91
    Translate31 "Translate_Treiber_in_Pressenrichtung": Direction edge [ZX plane of AxisSystem5 | YZ plane of AxisSystem5], ToTransfor Add44, Length -26.0455 {= - Sketch1.length(L1)}
  Add45 "Add_Treiber_Stellung_Offen": tool Body90
  Body92 "CopyBody_1_SCHIEBERBETT"
    Solid9: linked copy from another document
  Add46 "Add_CopyBody_1_SCHIEBERBETT": tool Body92
Body93 "SCHIEBERSTELLUNG_BEI_AUFTREFFEN_AUF_TREIBER"
  Body94 "Schieberkoerper_auf_Treiber"
    Body95 "CopyBody_2_SCHIEBERKOERPER"
      Solid10: linked copy from another document
    Add47 "Add_CopyBody_2_SCHIEBERKOERPER": tool Body95
    Translate32 "Translate_in_Schieberrichtung": Direction sketch element, ToTransfor Add47, Length -21.8548 {= - Sketch1.length(L2)}
    Translate33 "Translate_in_Vorbeschleunigung_Richtung": Direction sketch element, ToTransfor Translate32, Length 0 {= - Vorbeschleunigung_Hub}
  Add48 "Add_Schieberkoerper_auf_Treiber": tool Body94
  Body96 "Schieberbett_Stellung_auf_Treiber"
    Body97 "CopyBody_2_SCHIEBERBETT"
      Solid11: linked copy from another document
    Add49 "Add_CopyBody_2_SCHIEBERBETT": tool Body97
    Translate34 "Translate_Schieberbett_in_Pressenrichtung": Direction edge [ZX plane of AxisSystem4 | YZ plane of AxisSystem4], ToTransfor Add49, Length -26.0455 {= - Sketch1.length(L1)}
  Add50 "Add_Schieberbett_Stellung_auf_Treiber": tool Body96
  Body98 "CopyBody_2_TREIBER"
    Solid12: linked copy from another document
  Add51 "CopyBody_2_TREIBER": tool Body98
Relations
  rule "Rule__Achsensteuerung":
    /*Rule created by mn64751 17.04.2023*/
    if FP__Einfuegepunkt == "OEM_Standard"
    	Point2.Z = Nullbohrung_zu_ArbFl
    else if FP__Einfuegepunkt == "Naams_Standard"
    	Point2.Z = Nullbohrung_zu_ArbFl + Naams_Punkt
    else if FP__Einfuegepunkt == "Voest_Standard"
    	Point2.Z = 0mm
    /*
    Message("Wert = #",Werteliste_Schraube_Ts1->GetItem(3)->IsSupporting("Length"))
    */
  design table "DesignTable_O-KS_O-BS_O-ES", configuration 17, drives Vorbeschleunigung, Vorbeschleunigung_Hub, Winkel_Alpha, Winkel_Beta, Gasdruckfederweg, Naams_Punkt, Nullbohrung_zu_ArbFl, Nullbohrung_zu_Anschlag, Bauhoehe, Treibersohle, Treiberschulter, Schieberbett_Sohle, Schieberbett_Schulter, TL, Tb, Th, Tfb, Tfh, T1, Tw1, T2, T3, T4, T5, T10, Tw10, T11, Tw11, T12, T13, Tw13, T14, T15, T16, T17, T20, T21, T22, T23, BL, Bb, Bfh, B1, B2, B3, B4, B5, B6, B7, B10, B11, Bw1, Bw2, Bk1, Bk2, Bkl, Bkb, Bkd, B20, B21, B22, SAb, SAh, SAa, SAk, SAd, SKa, SKb, SKl1, SKl2, SKh1, SKh2, SKh3, S1, S2, S3, S4, S5, S6, S7, S8, S10, SAs1, SAs2, Anzahl_Treiber, Arbeitsflaeche, Nullbohrung_D, TranspGewinde_D, TranspGewinde_L1, TranspGewinde_L2, Abstand_Treiber, SKl, Vorbeschleunigung_Winkel, Tvb, Tv1, Tv2, Nullbohrung_L1, Nullbohrung_L2, Treiber_Schulterhohe, Schieberbett_Schulterhohe, INFO_Version_Ausgabe, S11, S12, S13, S14
  Split5.Activity = Th <> 0mm
  rule "Rule__Steuerung_Anschlussgeometrie":
    if FP__Treiber_Auswahl_Schulterung =="max"
    {
    	Pad25.FirstLimit.Length = Treiber_Schulterhohe
    	Pad25.Activity = true
    	INFO__Schieberkraft = "maximale Schieberkraft"
    	Add33.Activity = true
    	Sketch12.distance(L5 P1) = TL - FP__Treiber_Fraesradius - 3mm
    	Sketch13.distance(V L1) = (FP__Treiber_Fraesradius *2)
    }
    else if FP__Treiber_Auswahl_Schulterung == "frei"
    {
    	Pad25.FirstLimit.Length = FP__Treiber_Hoehe_Schulter_frei
    	Pad25.Activity = true
    	INFO__Schieberkraft = "geringe Kraftuebertragung"
    	Add33.Activity = true
    	Sketch12.distance(L5 P1) = TL - FP__Treiber_Fraesradius - 3mm
    	Sketch13.distance(V L1) = (FP__Treiber_Fraesradius *2) - 3mm
    }
    else if FP__Treiber_Auswahl_Schulterung == "ohne"
    {
    	Pad25.FirstLimit.Length = Pad24.FirstLimit.Length
    	Pad25.Activity = false
    	INFO__Schieberkraft = "geringe Kraftuebertragung"
    	Add33.Activity = false
    	Sketch12.distance(L5 P1) = TL + 11mm
    	Sketch13.distance(V L1) = (FP__Treiber_Fraesradius *2)
    }
    if FP__Schieberbett_Auswahl_Schulterung =="max"
    {
    	Pad23.FirstLimit.Length = Schieberbett_Schulterhohe
    	Pad23.Activity = true
    	INFO___Schieberkraft = "maximale Schieberkraft"
    	Pocket46.Activity = true
    	Sketch31.distance(L5 P1) = BL - FP__Schieberbett_Fraesradius - 3mm
    	Sketch32.distance(V L1) = FP__Schieberbett_Fraesradius*2
    	Pocket47.Activity = true
    	Add30.Activity = false
    }
    else if FP__Schieberbett_Auswahl_Schulterung == "frei"
    {
    	Pad23.FirstLimit.Length = FP__Schieberbett_Hoehe_Schulter_frei
    	Pad23.Activity = true
    	INFO___Schieberkraft = "geringe Kraftuebertragung"
    	Pocket46.Activity = true
    	Sketch31.distance(L5 P1) = BL - FP__Schieberbett_Fraesradius - 3mm
    	Sketch32.distance(V L1) = (FP__Schieberbett_Fraesradius*2) - 3mm
    	Pocket47.Activity = true
    	Add30.Activity = false
    }
    else if FP__Schieberbett_Auswahl_Schulterung == "Passfeder"
    {
    	Pad23.FirstLimit.Length = Pad22.FirstLimit.Length
    	Pad23.Activity = false
    	INFO___Schieberkraft = "geringe Kraftuebertragung"
    	Pocket46.Activity = false
    	Sketch31.distance(L5 P1) = BL + 11mm
    	Sketch32.distance(V L1) = FP__Schieberbett_Fraesradius*2
    	Pocket47.Activity = false
    	Add30.Activity = true
    }
    else if FP__Schieberbett_Auswahl_Schulterung == "Passfeder und max"
    {
    	Pad23.FirstLimit.Length = Schieberbett_Schulterhohe
    	Pad23.Activity = true
    	INFO___Schieberkraft = "maximale Schieberkraft"
    	Pocket46.Activity = true
    	Sketch31.distance(L5 P1) = BL - FP__Schieberbett_Fraesradius - 3mm
    	Sketch32.distance(V L1) = FP__Schieberbett_Fraesradius*2
    	Pocket47.Activity = false
    	Add30.Activity = true
    }
    else if FP__Schieberbett_Auswahl_Schulterung == "ohne"
    {
    	Pad23.FirstLimit.Length = Pad22.FirstLimit.Length
    	Pad23.Activity = false
    	INFO___Schieberkraft = "geringe Kraftuebertragung"
    	Pocket46.Activity = false
    	Sketch31.distance(L5 P1) = BL + 11mm
    	Sketch32.distance(V L1) = FP__Schieberbett_Fraesradius*2
    	Pocket47.Activity = true
    	Add30.Activity = false
    }
  Pocket51.Activity = FP__Treiber_Schulterung_Freiguss
  Value = FP__Treiber_Fraesradius
  rule "Rule__Steuerung_Farben":
    if FP__Treiber_Auswahl_Schulterung =="max"
    {
    	Pocket53.Color = "#FFAFAF"
    	Mirror42.Color = "#FFAFAF"
    }
    else if FP__Treiber_Auswahl_Schulterung == "frei"
    {
    	Pocket53.Color = "#600000"
    	Mirror42.Color = "#600000"
    }
    else if FP__Treiber_Auswahl_Schulterung == "ohne"
    {
    	Pocket53.Color = "#600000"
    	Mirror42.Color = "#600000"
    }
    if FP__Schieberbett_Auswahl_Schulterung =="max"
    {
    	Pocket46.Color = "#FFAFAF"
    }
    else if FP__Schieberbett_Auswahl_Schulterung == "frei"
    {
    	Pocket46.Color = "#600000"
    }
    else if FP__Schieberbett_Auswahl_Schulterung == "Passfeder"
    {
    	Pocket46.Color = "#600000"
    }
    else if FP__Schieberbett_Auswahl_Schulterung == "Passfeder und max"
    {
    	Pocket46.Color = "#FFAFAF"
    }
    else if FP__Schieberbett_Auswahl_Schulterung == "ohne"
    {
    	Pocket46.Color = "#600000"
    }
    /*
    #600000 = Schruppen
    #FFAFAF = Schlichten
    */
  Pocket37.Activity = T16 <> 0mm
  Pocket44.Activity = FP__Schieberbett_Schulterung_Freiguss
  Value = FP__Schieberbett_Fraesradius
  AxisSystem8.Y = Abstand_Treiber
  Mirror1.Activity = Anzahl_Treiber == 2
  Mirror2.Activity = Anzahl_Treiber == 2
  Hole2.Activity = TranspGewinde_D <> 0mm
  Mirror6.Activity = TranspGewinde_D <> 0mm
  Mirror28.Activity = Anzahl_Treiber == 2
  Mirror40.Activity = Anzahl_Treiber == 2
  Mirror42.Activity = Anzahl_Treiber == 2
  Mirror41.Activity = Anzahl_Treiber == 2
  Mirror45.Activity = Anzahl_Treiber == 2
  Mirror48.Activity = Anzahl_Treiber == 2
  rule "Rule__Steuerung_Umrechnungsfaktor":
    if FP__Variante_Schiebertyp == "O-KS" OR FP__Variante_Schiebertyp == "KS-OT"
    	Kraftfeld_Umrechnungsfaktor = 1
    else if FP__Variante_Schiebertyp == "O-BS"
    {
    	if FP__Garantierte_Standzeit->Search("Stufe 1", 1, false) <> -1
    		Kraftfeld_Umrechnungsfaktor = 0.75
    	else if FP__Garantierte_Standzeit->Search("Stufe 2", 1, false) <> -1
    		Kraftfeld_Umrechnungsfaktor = 0.5
    }
    else if FP__Variante_Schiebertyp == "O-ES"
    {
    	if FP__Variante_Schieberbreite == "50"
    	{
    		if FP__Garantierte_Standzeit->Search("Stufe 1", 1, false) <> -1
    			Kraftfeld_Umrechnungsfaktor = 1
    		else if FP__Garantierte_Standzeit->Search("Stufe 2", 1, false) <> -1
    			Kraftfeld_Umrechnungsfaktor = 0.75
    	}
    	else
    	{
    		if FP__Garantierte_Standzeit->Search("Stufe 1", 1, false) <> -1
    			Kraftfeld_Umrechnungsfaktor = 0.4
    		else if FP__Garantierte_Standzeit->Search("Stufe 2", 1, false) <> -1
    			Kraftfeld_Umrechnungsfaktor = 0.3
    	}
    }
  Pad20.Activity = Vorbeschleunigung
  Pocket42.Activity = Vorbeschleunigung
  `Thickness1.Offset##1##` = ThickSurface1.TopOffset
  Pad7.Activity = Vorbeschleunigung
  Pad8.Activity = Vorbeschleunigung
  ThickSurface1.Activity = Vorbeschleunigung
  Thickness1.Activity = Vorbeschleunigung
  Extrude1.Activity = Vorbeschleunigung
  Extract1.Activity = Vorbeschleunigung
  Remove1.Activity = FP__Variante_Schiebertyp == "KS-OT"
  Pocket1.Activity = FP__Variante_Schiebertyp == "KS-OT"
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  design table, configuration 0
  `Thickness3.Offset##1##` = - Plane16.Offset
  Remove30.Activity = Vorbeschleunigung
  Translate33.Activity = Vorbeschleunigung
  Mirror9.Activity = FP__Variante_Schiebertyp == "KS-OT"
  Remove8.Activity = FP__Variante_Schiebertyp == "KS-OT"
  Pocket7.Activity = FP__Variante_Schiebertyp == "KS-OT"
  Point7 = centerofgravity(fill(Sketch2))
  Point8 = centerofgravity(fill(Sketch3))
  Point9 = centerofgravity(fill(Sketch4))
  Point10 = centerofgravity(fill(Sketch5))
  Split2.Activity = Anzahl_Treiber == 2
  HP__OEM_Vorgabe_START_Achsensystem_Ausrichtung = false
  `Thickness5.Offset##1##` = Gasdruckfederweg
  Add4.Activity = S12 <> 0mm
  Remove22.Activity = S12 <> 0mm
  Remove6.Activity = S12 <> 0mm